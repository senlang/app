# Keil uVision project UCOSII-2.uvproj, settings and files
target stm_project (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\inc;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\inc;..\HARDWARE\BEEP;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\NET\device\inc;..\NET\protocol\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_exti.c
  group HARDWARE
    ../HARDWARE/src/: iwdg.c key.c led.c motor.c track.c
  group SYSTEM
    ../SYSTEM/src/: delay.c sys.c usart.c
  group USER
    ./: main.c
  group PROTOCOL
    ../NET/protocol/src/: stm32_protocol.c stm32_uart1_main.c stm32_uart2_main.c
  group DEVICE
    ../NET/device/src/: stm32_uart1.c stm32_uart2.c
